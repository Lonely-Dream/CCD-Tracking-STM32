# Keil uVision project Chariot.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Chariot +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Code\APP;..\Code\Libraries\CMSIS;..\Code\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Code\Public;..\Code\User
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../Code/User/: main.c stm32f10x_it.c
  group Startup
    ../Code/Libraries/CMSIS/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ../Code/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../Code/Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group APP
    ../Code/APP/: Motor.c Sensor_inf.c SteeringGear.c adc.c TSL1401.c usart.c
  group Public
    ../Code/Public/: system.c SysTick.c
